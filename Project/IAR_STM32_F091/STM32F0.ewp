# IAR project STM32F0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091VC ST STM32F091VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F091; DEMO_STM32F091
  ICCARM.CCIncludePath2: ..\..\Libraries\Check\Inc; ..\..\Libraries\Info\Inc; ..\..\Libraries\Mbed\tls; ..\..\Libraries\Convert\Inc; ..\..\Libraries\trace\Inc; ..\..\Devices\basic\Inc\STM32F0xx\cmsis; ..\..\Devices\basic\Inc\STM32F0xx\Interrupts; ..\..\Devices\basic\Inc\STM32F0xx\STM32F0xx_StdPeriph_Lib; ..\..\Devices\basic\Inc; ..\..\Devices\battery\Inc; ..\..\Devices\buzzer\Inc; ..\..\Devices\common\Inc; ..\..\Devices\lcd\Inc; ..\..\Devices\keys\Inc; ..\..\Devices\leds\Inc; ..\..\Devices\relay\Inc; ..\..\Devices\serial\Inc; ..\..\Devices\eeprom\Inc; ..\..\Devices\rtc\Inc; ..\..\Devices\metering\Inc; ..\..\Devices\flash\Inc; ..\..\Devices\power\Inc; ..\..\Devices\sensor\Inc; ..\..\Kernel\Inc; ..\..\Tasks\Tasks\Inc; ..\..\Tasks\Comm\Inc; ..\..\Tasks\Protocols\Core\Inc; ..\..\Tasks\Protocols\proto_1107\Inc; ..\..\Tasks\Protocols\proto_dlms\Inc; ..\..\Tasks\Protocols\proto_dlt645\Inc; ..\..\Tasks\Protocols\proto_dlt698\Inc; ..\..\Tasks\Protocols\proto_modbus\Inc; ..\..\Tasks\Protocols\proto_xmodem\Inc; ..\..\Tasks\Timed\Inc; ..\..\Tasks\Calendar\Inc; ..\..\Tasks\Disconnect\Inc; ..\..\Tasks\Console\Inc; ..\..\Tasks\Display\Inc; ..\..\Tasks\Keyboard\Inc; ..\..\Tasks\Logger\Inc; ..\..\Tasks\Metering\Inc; ..\..\Tasks\Utilities\Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f091xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Devices/basic
    ../../Devices/basic/Src/: cpu.c delay.c jiffy.c power.c
  group Devices/basic/STM32F0xx/cmsis
    ../../Devices/basic/Src/STM32F0xx/cmsis/: startup_stm32f091.s system_stm32f0xx.c
  group Devices/basic/STM32F0xx/Interrupts
    ../../Devices/basic/Src/STM32F0xx/Interrupts/: stm32f0xx_it.c
  group Devices/basic/STM32F0xx/STM32F0xx_StdPeriph_Lib
    ../../Devices/basic/Src/STM32F0xx/STM32F0xx_StdPeriph_Lib/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Devices/battery
    ../../Devices/battery/Src/: battery.c
  group Devices/buzzer
    ../../Devices/buzzer/Src/: buzzer.c
  group Devices/eeprom
    ../../Devices/eeprom/Src/: eeprom.c eeprom_1.c eeprom_2.c
  group Devices/eeprom/low
    ../../Devices/eeprom/Src/: viic2.c
  group Devices/flash
    ../../Devices/flash/Src/: flash.c
  group Devices/flash/low
    ../../Devices/flash/Src/: vspi2.c
  group Devices/keys
    ../../Devices/keys/Src/: keys.c
  group Devices/lcd
    ../../Devices/lcd/Src/: lcd.c
  group Devices/lcd/low
    ../../Devices/lcd/Src/: viic3.c
  group Devices/leds
    ../../Devices/leds/Src/: leds.c
  group Devices/metering
    ../../Devices/metering/Src/: meter.c
  group Devices/metering/low
    ../../Devices/metering/Src/: vspi1.c
  group Devices/relay
    ../../Devices/relay/Src/: relay.c
  group Devices/rtc
    ../../Devices/rtc/Src/: rtc.c
  group Devices/rtc/low
    ../../Devices/rtc/Src/: viic1.c
  group Devices/rtc/stubs
    ../../Devices/rtc/Src/: clock.c getzone.c time.c time64.c
  group Devices/sensor
    ../../Devices/sensor/Src/: button.c magnetic.c
  group Devices/serial/console
    ../../Devices/serial/Src/: console.c
  group Devices/serial/infrared/low
    ../../Devices/serial/Src/: vuart3.c
  group Devices/serial/module/low
    ../../Devices/serial/Src/: vuart4.c
  group Devices/serial/rs485
    ../../Devices/serial/Src/: rs485_1.c rs485_2.c
  group Devices/serial/rs485/low
    ../../Devices/serial/Src/: vuart1.c vuart2.c
  group Docs
    ../../Docs/: 00_naming_convention.txt 00_planning.txt 00_readme.txt
    ./: stm32f091xC.icf
  group Kernel
    ../../Kernel/Src/: disk.c heap.c kernel.c nvram.c
  group Libraries/Convert
    ../../Libraries/Convert/Src/: axdr.c bcd.c
  group Libraries/Info
    ../../Libraries/Info/Src/: info.c
  group Libraries/Mbed/tls
    ../../Libraries/Mbed/tls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Libraries/Trace
    ../../Libraries/trace/Src/: trace.c
  group Libraries/Verify
    ../../Libraries/Check/Src/: crc.c ecc.c
  group Tasks/Calendar
    ../../Tasks/Calendar/Src/: task_calendar.c
  group Tasks/Comm
    ../../Tasks/Comm/Src/: task_comm.c
  group Tasks/Console
    ../../Tasks/Console/Src/: task_console.c
  group Tasks/Disconnect
    ../../Tasks/Disconnect/Src/: task_disconnect.c
  group Tasks/Display
    ../../Tasks/Display/Src/: task_display.c
  group Tasks/Keyboard
    ../../Tasks/Keyboard/Src/: task_keyboard.c
  group Tasks/Logger
    ../../Tasks/Logger/Src/: task_logger.c
  group Tasks/Metering
    ../../Tasks/Metering/Src/: task_metering.c
  group Tasks/Protocols/Core
    ../../Tasks/Protocols/Core/Src/: task_protocol.c
  group Tasks/Protocols/proto_dlms
    ../../Tasks/Protocols/proto_dlms/Src/: cosem_objects.c cosem_objects_association.c cosem_objects_clock.c cosem_objects_data.c cosem_objects_exception.c cosem_objects_extendedregister.c cosem_objects_hdlc_setup.c cosem_objects_imagetransfer.c cosem_objects_register.c cosem_objects_security_setup.c dlms_application.c dlms_association.c dlms_lexicon.c dlms_utilities.c hdlc_datalink.c proto_dlms.c
  group Tasks/Protocols/proto_xmodem
    ../../Tasks/Protocols/proto_xmodem/Src/: proto_xmodem.c
  group Tasks/Tasks
    ../../Tasks/Tasks/Src/: tasks.c
  group Tasks/Timed
    ../../Tasks/Timed/Src/: task_timed.c
